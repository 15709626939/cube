# IAR project vcan_Kinetis.ewp, settings and files
configuration MK66FX18_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 Freescale MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG_MODE; ARM_MATH_CM4; MK66F18; MK66FX18; FPU_USED
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB; $TOOLKIT_DIR$\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vcan_Kinetis.hex
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K66X1M.icf
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MK66FX18_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FN1M0xxx15 Freescale MK60FN1M0xxx15
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK66F18; MK66FX18; FPU_USED
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: vcan_Kinetis.srec
  group AD_DEAL
    ../../App/: ad_deal.c
    ../../App/Inc/: ad_deal.h
  group App
    ../../App/: enter.h MK66_conf.c MK66_it.c
    ../../App/Inc/: MK66_conf.h MK66_it.h PORT_cfg.h
  group Board
    ../../Board/src/: VCAN_BMP.c VCAN_computer.c vcan_img2sd.c VCAN_key.c VCAN_key_event.c VCAN_LCD_ILI9325.c VCAN_LCD_ILI9341.c VCAN_LCD_ST7735R.c VCAN_LCD_ST7735S.c VCAN_LED.C VCAN_MMA7455.c VCAN_NRF24L0.c VCAN_NRF24L0_MSG.c VCAN_OV7725_Eagle.c VCAN_RTC_count.C VCAN_SCCB.c vcan_sd_app.c Vcan_touch.c VCAN_TSL1401.c VCAN_UI_VAR.c
  group CAMERA_DEAL
    ../../App/: camera_deal.c camera_deal.h feature.c
    ../../App/Inc/: feature.h
  group Chip
    ../../Chip/inc/: common.h
    ../../Chip/src/: misc.c MK66_adc.c MK66_dma.c MK66_flexbus.c MK66_gpio.c MK66_i2c.c MK66_port.c MK66_rtc.c MK66_sdhc.c MK66_spi.c MK66_uart.c MK66_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK66FX18.s system_MK66FX18.c
  group DIRECTION_CONTROL
    ../../App/: direction_control.c
    ../../App/Inc/: direction_control.h
  group HC-SR04
    ../../App/: hc-sr04.c
    ../../App/Inc/: hc-sr04.h
  group LIB/FatFs
    ../../Lib/FatFs/: diskio.c ff.c
  group MOTOR_CONTROL
    ../../App/: motor_control.c
    ../../App/Inc/: motor_control.h
  group USER
    ../../App/: define.h main.c
